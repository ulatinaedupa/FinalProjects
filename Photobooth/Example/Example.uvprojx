# Keil uVision project Example.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example
  c flags: Optim=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
    ./: example.c USBH_MSC.c ImageViewerDialogDLG.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: Example
  c flags: Optim=4
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.11.0, File System:Drive:USB 6.11.0, USB:CORE 6.13.0, USB:Device:MSC 6.13.0, USB:Host 6.13.0, USB:Host:MSC 6.13.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 2.8, CMSIS Driver:SPI 2.11, CMSIS Driver:USB Host:High-speed 2.22, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:DMA2D 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:LTDC 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:Startup 2.6.2, Graphics Display:STM32F429I-Discovery 1.0.2, Graphics:CORE 5.46.5, Graphics:Input Device:Touchscreen 5.46.5, Graphics:Tools:GUI Builder 5.46.5
